# Keil uVision project LED12A1.uvprojx, settings and files
target LED12A1 (ARM-ADS)
  device: STM32L073RZTx STMicroelectronics
  cpu: IROM(0x08000000-0x802FFFF) IRAM(0x20000000-0x20004FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: LED12A1
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L073xx
  c include: ../Inc;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../Drivers/BSP/LED12A1;../../../../../Drivers/BSP/Components/led1202;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include
  group Application/Custom
    ../Src/: bridge.c callbacks.c
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Drivers/BSP/Components/LED1202
    ../../../../../Drivers/BSP/Components/led1202/: led1202.c led1202_reg.c
  group Drivers/BSP/LED12A1
    ../../../../../Drivers/BSP/LED12A1/: led12a1.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
software components: CMSIS:CORE 4.3.0
