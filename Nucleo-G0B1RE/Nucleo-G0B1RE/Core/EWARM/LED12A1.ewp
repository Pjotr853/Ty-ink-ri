# IAR project LED12A1.ewp, settings and files
configuration LED12A1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\LED12A1; ..\..\..\..\..\Drivers\BSP\Components\led1202; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LED12A1_L0.bin
  ILINK.IlinkOutputFile: LED12A1.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Custom
    ../Src/: bridge.c callbacks.c
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Drivers/BSP/Components/LED1202
    ../../../../../Drivers/BSP/Components/led1202/: led1202.c led1202_reg.c
  group Drivers/BSP/LED12A1
    ../../../../../Drivers/BSP/LED12A1/: led12a1.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c
